# Keil uVision project AT24C02.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: AT24C02 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h LCD1602.c LCD1602.h I2C.c I2C.h AT24C02.c AT24C02.h Key.c Key.h Leds.c Leds.h Timer0.c Timer0.h
