#include <REGX52.H>
#include <Delay.h>
#include <Led8x8.h>
unsigned char Led[]={
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
	0x00,0xC3,0xC3,0xFF,0xFF,0xC3,0xC3,0x00,//I
	0x00,0xFF,0xFF,0x03,0x03,0x03,0x03,0x00,//L
	0x00,0x7E,0x81,0x81,0x81,0x81,0x7E,0x00,//O
	0x00,0x70,0x0C,0x02,0x02,0x0C,0x70,0x00,//V
	0x00,0xFF,0x99,0x99,0x99,0x99,0x99,0x00,//E
	0x00,0x7C,0x02,0x02,0x02,0x02,0x7C,0x00,//U

	0x00,0x7E,0x42,0x42,0x42,0x3C,0x00,0x00,//D
	0x00,0xC0,0x60,0x3E,0x3E,0x60,0xC0,0x00,//Y
	0x00,0x00,0x46,0x42,0x7E,0x40,0x00,0x00,//J
	0x00,0x00,0x00,0xFB,0xFB,0x00,0x00,0x00,//!
	
	0x70,0xF8,0xFC,0x7E,0x7E,0xFC,0xF8,0x70,//HEART
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
};
	

void main()
{
	unsigned char i;
	unsigned char j;
	unsigned char offset = 0;
	unsigned char count = 0;
	while(1)
	{
		
			for(i = 0;i < 8;i++)
			{
				Led8x8(i,Led[i + offset]);
			}
			count++;
			if(count >= 8 )
			{
				count = 0;
				offset++;
				if(offset >= 96)
					offset = 0;
			}
			
			
	}
}
