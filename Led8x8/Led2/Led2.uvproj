# Keil uVision project Led2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Led2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Led8x8.c Led8x8.h Delay.c Delay.h Timer0.c Timer0.h
